## conf/machine/include/torizon-sb-x86-testing.inc
```bitbake
# local.conf includes conf/machine/include/${MACHINE}.inc
require conf/machine/include/intel-corei7-64.inc
```
